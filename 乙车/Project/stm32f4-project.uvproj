# Keil uVision project stm32f4-project.uvproj, settings and files
target stm32f4-project (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4-project +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Drivers;..\User;..\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../Libraries/CMSIS/: startup_stm32f40xx.s system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_i2c.c stm32f4xx_dma.c
  group Drivers
    ../Drivers/: delay.c usart.c gpio.c timer.c spi.c pwm.c exit.c capture.c adc.c micros_time.c
  group Modules
    ../Modules/: remote_control.c motor.c stm32f4_discovery.c light_senser.c pid.c
  group User
    ../User/: main.c stm32f4xx_it.c util.c control.c
  group LCD
    ../Modules/LCD/: font.c lcd.c touch.c
  group Doc
    ../Doc/: 外设资源.txt STM32F407IGT6引脚定义.txt
